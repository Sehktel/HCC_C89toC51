# Keil uVision project 0_interrupt_0.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S4051 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0xFFF) CLOCK(20000000)
  output: 0_interrupt_0 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: 0_interrupt_0.c
