# Keil uVision project test1.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S4051 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0xFFF) CLOCK(20000000)
  output: test1
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: test1.c
