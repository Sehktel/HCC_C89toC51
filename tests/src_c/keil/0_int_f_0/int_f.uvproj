# Keil uVision project int_f.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S4051 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0xFFF) CLOCK(20000000)
  output: int_f
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 int_f.c
