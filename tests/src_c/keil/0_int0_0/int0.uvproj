# Keil uVision project int0.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S4051 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0xFFF) CLOCK(20000000)
  output: int0 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: int0.c
